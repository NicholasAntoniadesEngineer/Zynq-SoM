# Repository NicholasAntoniadesEngineer/Zynq-SoM (continued)

## KiCad design carrier/Zynq_Carrier.kicad_pcb (continued)

Schematic: hdmi_tx.kicad_sch, HDMI TX: TPD12S016 + HDMI-A receptacle

Parts:
C14001, C14002, C14003: 100n; C_0603_1608Metric; LCSC C14663
C14004: 1u; C_0603_1608Metric; LCSC C15849
C14005: 10u; C_0805_2012Metric; LCSC C15850
J14001: HDMI-019S; LCSC C111617
R14001, R14002: 10k; R_0603_1608Metric; LCSC C25804
TP14001: +5V_HDMI_TX; TestPoint_Pad_D1.5mm
TP14002: ZYNQ_HDMI_TX_SCL; TestPoint_Pad_D1.5mm
TP14003: ZYNQ_HDMI_TX_SDA; TestPoint_Pad_D1.5mm
U14001: TPD12S016PWR; LCSC C201665

Connections:
+3V3_HDMI_TX: C14001.1, C14005.1, R14001.1, R14002.1, U14001.24 (VCCA); also elsewhere on the board
+5V_HDMI_TX: C14002.1, TP14001.1, U14001.11 (VCC5V); also elsewhere on the board
/hdmi_tx/HDMI_TX_CON_5V0: C14003.1, C14004.1, J14001.18 (+5V), U14001.13 (5V_OUT)
/hdmi_tx/HDMI_TX_CON_CEC: J14001.13 (CEC), U14001.7 (CEC_B)
/hdmi_tx/HDMI_TX_CON_HPD: J14001.19 (HOT_PLUG_DET), U14001.10 (HPD_B-)
/hdmi_tx/HDMI_TX_CON_SCL: J14001.15 (I2C-CLK), U14001.8 (SCL_B)
/hdmi_tx/HDMI_TX_CON_SDA: J14001.16 (I2C_DATA), U14001.9 (SDA_B)
CHASSIS_GND: J14001.20 (SHD), J14001.21 (SHD), J14001.22 (SHD), J14001.23 (SHD); also elsewhere on the board
GND: C14001.2, C14002.2, C14003.2, C14004.2, C14005.2, J14001.2 (D2_SHIELD), J14001.5 (D1_SHIELD), J14001.8 (D0_SHIELD), J14001.11 (CK_SHIELD), J14001.17 (GND), U14001.6 (GND), U14001.14 (GND), U14001.19 (GND); also elsewhere on the board
unnamed: R14002.2, U14001.12 (CT_HPD)
unnamed: R14001.2, U14001.5 (LS_OE)
ZYNQ_HDMI_TX_CEC: U14001.1 (CEC_A); also elsewhere on the board
ZYNQ_HDMI_TX_HPD: U14001.4 (HPD_A-); also elsewhere on the board
ZYNQ_HDMI_TX_SCL: TP14002.1, U14001.2 (SCL_A); also elsewhere on the board
ZYNQ_HDMI_TX_SDA: TP14003.1, U14001.3 (SDA_A); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_0_N: J14001.9 (D0-), U14001.17 (D0-); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_0_P: J14001.7 (D0+), U14001.18 (D0+); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_1_N: J14001.6 (D1-), U14001.20 (D1-); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_1_P: J14001.4 (D1+), U14001.21 (D1+); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_2_N: J14001.3 (D2-), U14001.22 (D2-); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_2_P: J14001.1 (D2+), U14001.23 (D2+); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_CLK_N: J14001.12 (CK-), U14001.15 (CLK-); also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_CLK_P: J14001.10 (CK+), U14001.16 (CLK+); also elsewhere on the board

Schematic: lcd.kicad_sch, 40-pin TTL RGB LCD + SY7201 backlight

Parts:
C15001, C15004: 10u; C_0805_2012Metric; LCSC C15850
C15002: 2.2u; C_0805_2012Metric; LCSC C125847
C15003, C15006: 100n; C_0603_1608Metric; LCSC C14663
C15005: 1u; C_0603_1608Metric; LCSC C15849
D15001: SS34; D_SMA; LCSC C8678
J15001: AFC07-S40FCA-00; LCSC C262572
L15001: 10uH; SWPA4030S100MT; LCSC C38117
R15001: 1.5R; R_0603_1608Metric; LCSC C22769
R15002, R15003: 4k7; R_0603_1608Metric; LCSC C23162
R15004, R15005: 100k; R_0603_1608Metric; LCSC C25803
R15006: 10k; R_0603_1608Metric; LCSC C25804
R15007: 22R; R_0603_1608Metric; LCSC C23345
TP15001: +5V_LCD; TestPoint_Pad_D1.5mm
TP15002: LCD_CTP_SDA; TestPoint_Pad_D1.5mm
TP15003: LCD_CTP_SCL; TestPoint_Pad_D1.5mm
U15001: SY7201ABC; LCSC C82173
U15002: USBLC6-2SC6; LCSC C7519

Connections:
+3V3: C15006.1, U15002.5; also elsewhere on the board
+3V3_LCD: C15003.1, C15004.1, J15001.4, R15002.2, R15003.2, R15006.2; also elsewhere on the board
+5V_LCD: C15001.1, C15005.1, L15001.1, TP15001.1, U15001.6 (IN); also elsewhere on the board
/lcd/CTP_SCL_FFC: J15001.38, U15002.3
/lcd/CTP_SDA_FFC: J15001.37, U15002.1
/lcd/LCD_VLED_N: J15001.1, R15001.1, U15001.3 (FB)
/lcd/LCD_VLED_P: C15002.1, D15001.1 (K), J15001.2, U15001.5 (OVP)
GND: C15001.2, C15002.2, C15003.2, C15004.2, C15005.2, C15006.2, J15001.3, J15001.29, J15001.36, R15001.2, R15004.2, R15005.2, U15001.2 (GND), U15002.2; also elsewhere on the board
LCD_B0: J15001.21; also elsewhere on the board
LCD_B1: J15001.22; also elsewhere on the board
LCD_B2: J15001.23; also elsewhere on the board
LCD_B3: J15001.24; also elsewhere on the board
LCD_B4: J15001.25; also elsewhere on the board
LCD_B5: J15001.26; also elsewhere on the board
LCD_B6: J15001.27; also elsewhere on the board
LCD_B7: J15001.28; also elsewhere on the board
LCD_BL_PWM: R15004.1, U15001.4 (EN/PWM); also elsewhere on the board
LCD_CTP_INT: J15001.40; also elsewhere on the board
LCD_CTP_RST: J15001.39, R15005.1; also elsewhere on the board
LCD_CTP_SCL: R15003.1, TP15003.1, U15002.4; also elsewhere on the board
LCD_CTP_SDA: R15002.1, TP15002.1, U15002.6; also elsewhere on the board
LCD_DE: J15001.34; also elsewhere on the board
LCD_DISP: J15001.31, R15006.1; also elsewhere on the board
LCD_G0: J15001.13; also elsewhere on the board
LCD_G1: J15001.14; also elsewhere on the board
LCD_G2: J15001.15; also elsewhere on the board
LCD_G3: J15001.16; also elsewhere on the board
LCD_G4: J15001.17; also elsewhere on the board
LCD_G5: J15001.18; also elsewhere on the board
LCD_G6: J15001.19; also elsewhere on the board
LCD_G7: J15001.20; also elsewhere on the board
LCD_HSYNC: J15001.32; also elsewhere on the board
LCD_PCLK: R15007.2; also elsewhere on the board
LCD_R0: J15001.5; also elsewhere on the board
LCD_R1: J15001.6; also elsewhere on the board
LCD_R2: J15001.7; also elsewhere on the board
LCD_R3: J15001.8; also elsewhere on the board
LCD_R4: J15001.9; also elsewhere on the board
LCD_R5: J15001.10; also elsewhere on the board
LCD_R6: J15001.11; also elsewhere on the board
LCD_R7: J15001.12; also elsewhere on the board
LCD_VSYNC: J15001.33; also elsewhere on the board
unnamed: D15001.2 (A), L15001.2, U15001.1 (LX)
unnamed: J15001.30, R15007.1

Schematic: mechanical.kicad_sch, Mechanical: M3 mounts + chassis-GND

Parts:
H34001, H34002, H34003, H34004: MountingHole_M3; MountingHole_3.2mm_M3_Pad

Connections:
CHASSIS_GND: H34001.1, H34002.1, H34003.1, H34004.1; also elsewhere on the board

Schematic: microsd.kicad_sch, microSD slot (1.8V SoM <-> 3.3V card,

Parts:
C16001, C16002, C16004: 100n; C_0603_1608Metric; LCSC C14663
C16003: 22u; C_0805_2012Metric; LCSC C45783
J16001: TF-01A; LCSC C91145
R16001, R16002, R16003, R16004, R16005: 100k; R_0603_1608Metric; LCSC C25803
R16006: 10k; R_0603_1608Metric; LCSC C25804
TP16001: SDIO_CMD; TestPoint_Pad_D1.5mm
TP16002: SDIO_CLK; TestPoint_Pad_D1.5mm
U16001: TXS02612RTWR; LCSC C140276
U16002: TPD6E001RSER; LCSC C1973318

Connections:
+1V8: C16001.1, U16001.5 (VCCA); also elsewhere on the board
+3V3_SD: C16002.1, C16003.1, C16004.1, J16001.4 (VDD), R16001.1, R16002.1, R16003.1, R16004.1, R16005.1, R16006.1, U16001.17 (VCCB1), U16001.21 (VCCB0), U16002.10 (VCC); also elsewhere on the board
/microsd/SD_CARD_CLK: J16001.5 (CLK(SCLK)), U16001.19 (CLKB0), U16002.1 (IO1)
/microsd/SD_CARD_CMD: J16001.3 (CMD(DI)), R16001.2, U16001.20 (CMDB0), U16002.2 (IO2)
/microsd/SD_CARD_D0: J16001.7 (DAT0(D0)), R16002.2, U16001.18 (DAT0B0), U16002.3 (IO3)
/microsd/SD_CARD_D1: J16001.8 (DAT1(RSV)), R16003.2, U16001.16 (DAT1B0), U16002.6 (IO4)
/microsd/SD_CARD_D2: J16001.1 (DAT2(RSV)), R16004.2, U16001.23 (DAT2B0), U16002.7 (IO5)
/microsd/SD_CARD_D3: J16001.2 (CDDAT3(CS)), R16005.2, U16001.22 (DAT3B0), U16002.8 (IO6)
GND: C16001.2, C16002.2, C16003.2, C16004.2, J16001.6 (VSS), J16001.10 (GND), J16001.11 (GND), J16001.12 (GND), J16001.13 (GND), U16001.2 (GND), U16001.11 (GND), U16001.24 (SEL), U16001.25 (EP), U16002.5 (GND); also elsewhere on the board
SDIO_CLK: TP16002.1, U16001.9 (CLKA); also elsewhere on the board
SDIO_CMD: TP16001.1, U16001.4 (CMDA); also elsewhere on the board
SDIO_D0: U16001.6 (DAT0A); also elsewhere on the board
SDIO_D1: U16001.7 (DAT1A); also elsewhere on the board
SDIO_D2: U16001.1 (DAT2A); also elsewhere on the board
SDIO_D3: U16001.3 (DAT3A); also elsewhere on the board
SD_CARD_DETECT: J16001.9 (CD), R16006.2; also elsewhere on the board

Schematic: motor_pwm.kicad_sch, 8-ch PWM/ESC output buffer (5V,

Parts:
C36001: 100n; C_0603_1608Metric; LCSC C14663
C36002, C36003: 10u; C_0805_2012Metric; LCSC C15850
D36001, D36002: SRV05-4; SOT-23-6; LCSC C2836319
J36001: HX PZ2.54-3x8P ZZ; HX_PZ2.54-3x8P_ZZ; LCSC C32713295
R36001: 10k; R_0603_1608Metric; LCSC C25804
R36002: 13k; R_0603_1608Metric; LCSC C22797
RN36001, RN36002: 4D03WGJ0330T5E; LCSC C25508
TP36001: +5V_MOTOR_IO; TestPoint_Pad_D1.5mm
U36001: SN74HCT245PWR; LCSC C6779
U36003: SY6280AAC; LCSC C55136

Connections:
+5V: C36001.1, C36002.1, D36001.5 (VP), D36002.5 (VP), R36001.1, U36001.1 (DIR), U36001.20 (VCC), U36003.4 (EN), U36003.5 (IN); also elsewhere on the board
+5V_MOTOR_IO: C36003.1, J36001.9, J36001.10, J36001.11, J36001.12, J36001.13, J36001.14, J36001.15, J36001.16, TP36001.1, U36003.1 (OUT)
/motor_pwm/ESC_OUT0: D36001.1 (IO1), J36001.1, RN36001.8
/motor_pwm/ESC_OUT1: D36001.3 (IO2), J36001.2, RN36001.7
/motor_pwm/ESC_OUT2: D36001.4 (IO3), J36001.3, RN36001.6
/motor_pwm/ESC_OUT3: D36001.6 (IO4), J36001.4, RN36001.5
/motor_pwm/ESC_OUT4: D36002.1 (IO1), J36001.5, RN36002.8
/motor_pwm/ESC_OUT5: D36002.3 (IO2), J36001.6, RN36002.7
/motor_pwm/ESC_OUT6: D36002.4 (IO3), J36001.7, RN36002.6
/motor_pwm/ESC_OUT7: D36002.6 (IO4), J36001.8, RN36002.5
/motor_pwm/ESC_SIG0: RN36001.1, U36001.18 (B1)
/motor_pwm/ESC_SIG1: RN36001.2, U36001.17 (B2)
/motor_pwm/ESC_SIG2: RN36001.3, U36001.16 (B3)
/motor_pwm/ESC_SIG3: RN36001.4, U36001.15 (B4)
/motor_pwm/ESC_SIG4: RN36002.1, U36001.14 (B5)
/motor_pwm/ESC_SIG5: RN36002.2, U36001.13 (B6)
/motor_pwm/ESC_SIG6: RN36002.3, U36001.12 (B7)
/motor_pwm/ESC_SIG7: RN36002.4, U36001.11 (B8)
ESC_BUF_OE_N: R36001.2, U36001.19 (#OE); also elsewhere on the board
ESC_PWM_IN0: U36001.2 (A1); also elsewhere on the board
ESC_PWM_IN1: U36001.3 (A2); also elsewhere on the board
ESC_PWM_IN2: U36001.4 (A3); also elsewhere on the board
ESC_PWM_IN3: U36001.5 (A4); also elsewhere on the board
ESC_PWM_IN4: U36001.6 (A5); also elsewhere on the board
ESC_PWM_IN5: U36001.7 (A6); also elsewhere on the board
ESC_PWM_IN6: U36001.8 (A7); also elsewhere on the board
ESC_PWM_IN7: U36001.9 (A8); also elsewhere on the board
GND: C36001.2, C36002.2, C36003.2, D36001.2 (VN), D36002.2 (VN), J36001.17, J36001.18, J36001.19, J36001.20, J36001.21, J36001.22, J36001.23, J36001.24, R36002.2, U36001.10 (GND), U36003.2 (GND); also elsewhere on the board
unnamed: R36002.1, U36003.3 (ISET)

Schematic: motor_sense.kicad_sch, ESC motor-rail telemetry: INA3221 +

Parts:
C37001, C37002: 100n; C_0603_1608Metric; LCSC C14663
C37003: 10u; C_0805_2012Metric; LCSC C15850
C37004: 470uF/35V; CP_Elec_10x10.5; LCSC C976030
D37001: SMBJ28A; LCSC C178227
J37002, J37003: XT60PW-M; LCSC C98732
R37001: 10k; R_0603_1608Metric; LCSC C25804
RS37001: 10mR; RLM12FTCMR010; LCSC C188070
U37002: INA3221AIRGVR; LCSC C181255

Connections:
+3V3_SC: C37002.1, C37003.1, R37001.1, U37002.4 (VS), U37002.16 (VPU); also elsewhere on the board
/motor_sense/ESC_VRAIL: C37004.1, J37003.2 (+), RS37001.2, U37002.11 (IN-1)
/motor_sense/ESC_VRAIL_IN: C37001.1, D37001.1 (C), J37002.2 (+), RS37001.1, U37002.12 (IN+1)
ESC_FAULT_N: R37001.2, U37002.9 (CRITICAL); also elsewhere on the board
GND: C37001.2, C37002.2, C37003.2, C37004.2, D37001.2 (A), J37002.1 (-), J37002.3, J37002.4, J37003.1 (-), J37003.3, J37003.4, U37002.1 (IN-3), U37002.2 (IN+3), U37002.3 (GND), U37002.14 (IN-2), U37002.15 (IN+2), U37002.17 (PAD); also elsewhere on the board
STM32_I2C2_SCL: U37002.6 (SCL); also elsewhere on the board
STM32_I2C2_SDA: U37002.5 (A0), U37002.7 (SDA); also elsewhere on the board

Schematic: pd_input.kicad_sch, Power inlet: USB-C PD 20V/3A + TPS26631

Parts:
C17001, C17004: 100n; C_0603_1608Metric; LCSC C14663
C17002: 10u; C_1210_3225Metric; LCSC C596319
C17003: 47n; C_0603_1608Metric; LCSC C1622
D17001: SMBJ22A; D_SMB; LCSC C10214
J17001: TYPE-C-31-M-12; LCSC C165948
R17003, R17006: 100k; R_0603_1608Metric; LCSC C25803
R17004: 5.49k; R_0603_1608Metric; LCSC C188263
R17005: 5.1k; R_0603_1608Metric; LCSC C23186
TP17001: +VBUS_IN; TestPoint_Pad_D1.5mm
TP17002: +VIN; TestPoint_Pad_D1.5mm
U17001: TPS26631PWPR; LCSC C2866319
U17002: USBLC6-2SC6; LCSC C7519

Connections:
+3V3_SC: C17004.1, R17006.1, U17002.5; also elsewhere on the board
+VBUS_IN: C17001.1, D17001.1 (K), J17001.A4B9 (VBUS), J17001.B4A9 (VBUS), R17003.1, TP17001.1, U17001.1 (IN), U17001.2 (IN), U17001.3 (IN), U17001.6 (IN_SYS), U17001.7 (UVLO); also elsewhere on the board
+VIN: C17002.1, TP17002.1, U17001.18 (OUT), U17001.19 (OUT), U17001.20 (OUT); also elsewhere on the board
/pd_input/PD_USB_DN_CONN: J17001.A7 (DN1), J17001.B7 (DN2), U17002.3
/pd_input/PD_USB_DP_CONN: J17001.A6 (DP1), J17001.B6 (DP2), U17002.1
CHASSIS_GND: J17001.1 (EH), J17001.2 (EH), J17001.3 (EH), J17001.4 (EH); also elsewhere on the board
GND: C17001.2, C17002.2, C17003.2, C17004.2, D17001.2 (A), J17001.A1B12 (GND), J17001.B1A12 (GND), R17004.2, R17005.2, U17001.9 (GND), U17001.12 (MODE), U17001.16 (PGTH), U17001.21 (EP), U17002.2; also elsewhere on the board
unnamed: R17005.1, U17001.11 (ILIM)
unnamed: R17003.2, R17004.1, U17001.8 (OVP)
unnamed: C17003.1, U17001.10 (dVdT)
PD_FLT_N: R17006.2, U17001.15 (FLT#); also elsewhere on the board
STM32_USB_CC1: J17001.A5 (CC1); also elsewhere on the board
STM32_USB_CC2: J17001.B5 (CC2); also elsewhere on the board
STM32_USB_D_N: U17002.4; also elsewhere on the board
STM32_USB_D_P: U17002.6; also elsewhere on the board

Schematic: pmod.kicad_sch, 2x Pmod host ports (bank 13, 200R

Parts:
C18001, C18003: 100n; C_0603_1608Metric; LCSC C14663
C18002, C18004: 10u; C_0805_2012Metric; LCSC C15850
J18001, J18002: DS1024-2x6R2; LCSC C49284652
R18001, R18002, R18003, R18004, R18005, R18006, R18007, R18008, R18009, R18010, R18011, R18012, R18013, R18014, R18015, R18016: 200R; R_0603_1608Metric; LCSC C8218
U18001, U18002, U18003, U18004: TPD4E1U06; TPD4E1U06DBVR; LCSC C124691

Connections:
+3V3_PMOD: C18001.1, C18002.1, C18003.1, C18004.1, J18001.11, J18001.12, J18002.11, J18002.12; also elsewhere on the board
GND: C18001.2, C18002.2, C18003.2, C18004.2, J18001.9, J18001.10, J18002.9, J18002.10, U18001.2 (GND), U18002.2 (GND), U18003.2 (GND), U18004.2 (GND); also elsewhere on the board
IO_L2_N_13: R18002.1, U18001.3 (D2+); also elsewhere on the board
IO_L2_P_13: R18001.1, U18001.1 (D1+); also elsewhere on the board
IO_L3_N_13: R18004.1, U18001.4 (D2-); also elsewhere on the board
IO_L3_P_13: R18003.1, U18001.6 (D1-); also elsewhere on the board
IO_L4_N_13: R18006.1, U18002.3 (D2+); also elsewhere on the board
IO_L4_P_13: R18005.1, U18002.1 (D1+); also elsewhere on the board
IO_L5P_13: R18007.1, U18002.6 (D1-); also elsewhere on the board
IO_L5_N_13: R18008.1, U18002.4 (D2-); also elsewhere on the board
IO_L7_N_13: R18010.1, U18003.3 (D2+); also elsewhere on the board
IO_L7_P_13: R18009.1, U18003.1 (D1+); also elsewhere on the board
IO_L8_N_13: R18012.1, U18003.4 (D2-); also elsewhere on the board
IO_L8_P_13: R18011.1, U18003.6 (D1-); also elsewhere on the board
IO_L9_DQS_N_13: R18014.1, U18004.3 (D2+); also elsewhere on the board
IO_L9_DQS_P_13: R18013.1, U18004.1 (D1+); also elsewhere on the board
IO_L10_N_13: R18016.1, U18004.4 (D2-); also elsewhere on the board
IO_L10_P_13: R18015.1, U18004.6 (D1-); also elsewhere on the board
unnamed: J18001.1, R18001.2
unnamed: J18001.2, R18005.2
unnamed: J18001.3, R18002.2
unnamed: J18001.4, R18006.2
unnamed: J18001.5, R18003.2
unnamed: J18001.6, R18007.2
unnamed: J18001.7, R18004.2
unnamed: J18001.8, R18008.2
unnamed: J18002.1, R18009.2
unnamed: J18002.2, R18013.2
unnamed: J18002.3, R18010.2
unnamed: J18002.4, R18014.2
unnamed: J18002.5, R18011.2
unnamed: J18002.6, R18015.2
unnamed: J18002.7, R18012.2
unnamed: J18002.8, R18016.2

Schematic: pmod_expansion.kicad_sch, Pmod expansion (2x6, bank 13, ESD,

Parts:
C19001, C19003, C19004: 100n; C_0603_1608Metric; LCSC C14663
C19002, C19005: 10u; C_0805_2012Metric; LCSC C15850
D19001: red; LED_0603_1608Metric; LCSC C2286
J19001: DS1024-2x6R2; LCSC C49284652
R19001: 13k; R_0603_1608Metric; LCSC C22797
R19002: 100k; R_0603_1608Metric; LCSC C25803
R19003: 330R; R_0603_1608Metric; LCSC C23138
SW19001: DSHP04TSGER; LCSC C3293144
TP19001: +3V3_PMODX; TestPoint_Pad_D1.5mm
U19001: SY6280AAC; LCSC C55136
U19002, U19003: TPD4E1U06; TPD4E1U06DBVR; LCSC C124691

Connections:
+3V3: C19001.1, C19002.1, SW19001.1, SW19001.3, SW19001.5, SW19001.7, U19001.5 (IN); also elsewhere on the board
+3V3_PMODX: C19003.1, C19004.1, C19005.1, D19001.2 (A), J19001.11, J19001.12, TP19001.1, U19001.1 (OUT)
/pmod_expansion/EN_PMODX: R19002.1, SW19001.8, U19001.4 (EN)
GND: C19001.2, C19002.2, C19003.2, C19004.2, C19005.2, J19001.9, J19001.10, R19001.2, R19002.2, R19003.2, U19001.2 (GND), U19002.2 (GND), U19003.2 (GND); also elsewhere on the board
unnamed: D19001.1 (K), R19003.1
unnamed: R19001.1, U19001.3 (ISET)
PMODX_IO1: J19001.1, U19002.1 (D1+); also elsewhere on the board
PMODX_IO2: J19001.3, U19002.3 (D2+); also elsewhere on the board
PMODX_IO3: J19001.5, U19002.6 (D1-); also elsewhere on the board
PMODX_IO4: J19001.7, U19002.4 (D2-); also elsewhere on the board
PMODX_IO5: J19001.2, U19003.1 (D1+); also elsewhere on the board
PMODX_IO6: J19001.4, U19003.3 (D2+); also elsewhere on the board
PMODX_IO7: J19001.6, U19003.6 (D1-); also elsewhere on the board
PMODX_IO8: J19001.8, U19003.4 (D2-); also elsewhere on the board

Schematic: power.kicad_sch, Power: +VIN->+5V->+3V3 bucks + +1V8

Parts:
C20001, C20004, C20007, C20009, C20025, C20029: 100n; C_0603_1608Metric; LCSC C14663
C20002, C20003: 10u; C_1206_3216Metric; LCSC C13585
C20005, C20006, C20008, C20010, C20011, C20026, C20030: 22u; C_0805_2012Metric; LCSC C45783
C20012, C20013, C20024, C20028, C20031, C20032: 1u; C_0603_1608Metric; LCSC C15849
C20023, C20027: 22p; C_0603_1608Metric; LCSC C1653
D20001, D20002, D20003: red; LED_0603_1608Metric; LCSC C2286
L20001, L20002: 10uH; SWPA8040S100MT; LCSC C37429
Q20001: AO3400A; SOT-23; MPN AO3400A; LCSC C20917
R20001: 40.2k; R_0603_1608Metric; LCSC C12447
R20002, R20005: 10k; R_0603_1608Metric; LCSC C25804
R20003, R20007, R20012, R20015: 1k; R_0603_1608Metric; LCSC C21190
R20004: 23.2k; R_0603_1608Metric; LCSC C23346
R20006, R20009: 330R; R_0603_1608Metric; LCSC C23138
R20008: 100k; R_0603_1608Metric; LCSC C25803
R20010, R20014: 22k; R_0603_1608Metric; LCSC C31850
R20011, R20013: 10R; R_0603_1608Metric; LCSC C22859
TP20001: +5V; TestPoint_Pad_D1.5mm
TP20002: +3V3; TestPoint_Pad_D1.5mm
TP20003: +1V8; TestPoint_Pad_D1.5mm
TP20004: GND; TestPoint_Pad_D1.5mm
U20001, U20002: LM61460AANRJRR; LCSC C2864505
U20003: AP2112K-1.8; SOT-23-5; MPN AP2112K-1.8TRG1; LCSC C176944

Connections:
+1V8: R20007.1, TP20003.1; also elsewhere on the board
+1V8_REG: C20013.1, U20003.5 (VOUT); also elsewhere on the board
+3V3: C20012.1, D20003.2 (A), TP20002.1, U20003.1 (VIN); also elsewhere on the board
+3V3_REG: C20010.1, C20011.1, C20023.1, D20002.2 (A), L20002.2, R20004.1, R20013.1; also elsewhere on the board
+5V: C20007.1, C20008.1, C20029.1, C20030.1, TP20001.1, U20002.8 (VIN1), U20002.12 (VIN2); also elsewhere on the board
+5V_REG: C20005.1, C20006.1, C20026.1, C20027.1, D20001.2 (A), L20001.2, R20001.1, R20011.1; also elsewhere on the board
+VIN_SYS: C20001.1, C20002.1, C20003.1, C20025.1, U20001.8 (VIN1), U20001.12 (VIN2); also elsewhere on the board
/power/BIAS_3V3: C20032.1, R20013.2, U20002.1 (BIAS)
/power/BIAS_5V0: C20028.1, R20011.2, U20001.1 (BIAS)
/power/RT_3V3: R20014.1, U20002.6 (RT)
/power/RT_5V0: R20010.1, U20001.6 (RT)
EN_1V8: U20003.3 (EN); also elsewhere on the board
EN_3V3: U20002.7 (EN/SYNC); also elsewhere on the board
EN_5V0: U20001.7 (EN/SYNC); also elsewhere on the board
GND: C20001.2, C20002.2, C20003.2, C20005.2, C20006.2, C20007.2, C20008.2, C20010.2, C20011.2, C20012.2, C20013.2, C20024.2, C20025.2, C20026.2, C20028.2, C20029.2, C20030.2, C20031.2, C20032.2, Q20001.2 (S), R20002.2, R20003.2, R20005.2, R20006.2, R20008.2, R20010.2, R20014.2, TP20004.1, U20001.3 (AGND), U20001.9 (PGND1), U20001.11 (PGND2), U20002.3 (AGND), U20002.9 (PGND1), U20002.11 (PGND2), U20003.2 (GND); also elsewhere on the board
unnamed: C20023.2, R20015.1
unnamed: C20027.2, R20012.1
unnamed: D20001.1 (K), R20003.1
unnamed: D20002.1 (K), R20006.1
unnamed: D20003.1 (K), R20009.1
unnamed: Q20001.3 (D), R20009.2
unnamed: Q20001.1 (G), R20007.2, R20008.1
unnamed: C20004.1, U20001.13 (RBOOT), U20001.14 (CBOOT)
unnamed: R20001.2, R20002.1, R20012.2, U20001.4 (FB)
unnamed: C20004.2, L20001.1, U20001.10 (SW)
unnamed: C20024.1, U20001.2 (VCC)
unnamed: C20009.1, U20002.13 (RBOOT), U20002.14 (CBOOT)
unnamed: R20004.2, R20005.1, R20015.2, U20002.4 (FB)
unnamed: C20009.2, L20002.1, U20002.10 (SW)
unnamed: C20031.1, U20002.2 (VCC)

Schematic: power_mon.kicad_sch, Rail telemetry: 2x INA3221 + shunts

Parts:
C21001, C21002: 100n; C_0603_1608Metric; LCSC C14663
C21003: 10u; C_0805_2012Metric; LCSC C15850
R21001: 10k; R_0603_1608Metric; LCSC C25804
RS21001, RS21002, RS21003: 10mR; RLM12FTCMR010; LCSC C188070
RS21004: 20mR; RLM12FTCMR020; LCSC C393094
U21001, U21002: INA3221AIRGVR; LCSC C181255

Connections:
+1V8: RS21004.2, U21002.11 (IN-1); also elsewhere on the board
+1V8_REG: RS21004.1, U21002.12 (IN+1); also elsewhere on the board
+3V3: RS21003.2, U21001.1 (IN-3); also elsewhere on the board
+3V3_REG: RS21003.1, U21001.2 (IN+3); also elsewhere on the board
+3V3_SC: C21001.1, C21002.1, C21003.1, R21001.1, U21001.4 (VS), U21001.16 (VPU), U21002.4 (VS), U21002.5 (A0), U21002.16 (VPU); also elsewhere on the board
+5V: RS21002.2, U21001.14 (IN-2); also elsewhere on the board
+5V_REG: RS21002.1, U21001.15 (IN+2); also elsewhere on the board
+VIN: RS21001.1, U21001.12 (IN+1); also elsewhere on the board
+VIN_SYS: RS21001.2, U21001.11 (IN-1); also elsewhere on the board
GND: C21001.2, C21002.2, C21003.2, U21001.3 (GND), U21001.5 (A0), U21001.17 (PAD), U21002.1 (IN-3), U21002.2 (IN+3), U21002.3 (GND), U21002.14 (IN-2), U21002.15 (IN+2), U21002.17 (PAD); also elsewhere on the board
PMON_ALERT_N: R21001.2, U21001.9 (CRITICAL), U21002.9 (CRITICAL); also elsewhere on the board
STM32_I2C2_SCL: U21001.6 (SCL), U21002.6 (SCL); also elsewhere on the board
STM32_I2C2_SDA: U21001.7 (SDA), U21002.7 (SDA); also elsewhere on the board

Schematic: power_som.kicad_sch, Power: +VIN -> +5V_SOM always-on buck

Parts:
C22014, C22017, C22025: 100n; C_0603_1608Metric; LCSC C14663
C22015, C22016: 10u; C_1206_3216Metric; LCSC C13585
C22018, C22019: 22u; C_0805_2012Metric; LCSC C45783
C22021: 22p; C_0603_1608Metric; LCSC C1653
C22022, C22023: 1u; C_0603_1608Metric; LCSC C15849
D22004: red; LED_0603_1608Metric; LCSC C2286
L22003: 10uH; SWPA8040S100MT; LCSC C37429
R22014: 47k5; R_0603_1608Metric; LCSC C23061
R22015: 13k; R_0603_1608Metric; LCSC C22797
R22016, R22019: 1k; R_0603_1608Metric; LCSC C21190
R22017: 10R; R_0603_1608Metric; LCSC C22859
R22018: 22k; R_0603_1608Metric; LCSC C31850
TP22001: +5V_SOM; TestPoint_Pad_D1.5mm
U22004: LM61460AANRJRR; LCSC C2864505

Connections:
+5V_SOM: C22018.1, C22019.1, C22021.1, D22004.2 (A), L22003.2, R22014.1, R22017.1, TP22001.1; also elsewhere on the board
+VIN_SYS: C22014.1, C22015.1, C22016.1, C22025.1, U22004.7 (EN/SYNC), U22004.8 (VIN1), U22004.12 (VIN2); also elsewhere on the board
/power_som/BIAS_5V_SOM: C22023.1, R22017.2, U22004.1 (BIAS)
/power_som/RT_5V_SOM: R22018.1, U22004.6 (RT)
GND: C22014.2, C22015.2, C22016.2, C22018.2, C22019.2, C22022.2, C22023.2, C22025.2, R22015.2, R22016.2, R22018.2, U22004.3 (AGND), U22004.9 (PGND1), U22004.11 (PGND2); also elsewhere on the board
unnamed: C22021.2, R22019.1
unnamed: D22004.1 (K), R22016.1
unnamed: C22017.1, U22004.13 (RBOOT), U22004.14 (CBOOT)
unnamed: R22014.2, R22015.1, R22019.2, U22004.4 (FB)
unnamed: C22017.2, L22003.1, U22004.10 (SW)
unnamed: C22022.1, U22004.2 (VCC)

Schematic: rj45_connector.kicad_sch, RJ45 8P8C jack (plain, ext. magnetics)

Parts:
J23001: KH-5224-8P8C-D; LCSC C2828085
R23001, R23002: 330R; R_0603_1608Metric; LCSC C23138

Connections:
+3V3: R23001.1, R23002.1; also elsewhere on the board
CHASSIS_GND: J23001.13 (SHELL); also elsewhere on the board
ETH_LINE_MDI_0_N: J23001.2; also elsewhere on the board
ETH_LINE_MDI_0_P: J23001.1; also elsewhere on the board
ETH_LINE_MDI_1_N: J23001.6; also elsewhere on the board
ETH_LINE_MDI_1_P: J23001.3; also elsewhere on the board
ETH_LINE_MDI_2_N: J23001.5; also elsewhere on the board
ETH_LINE_MDI_2_P: J23001.4; also elsewhere on the board
ETH_LINE_MDI_3_N: J23001.8; also elsewhere on the board
ETH_LINE_MDI_3_P: J23001.7; also elsewhere on the board
GND: J23001.10 (LED-L-), J23001.12 (LED-R-); also elsewhere on the board
unnamed: J23001.9 (LED-L+), R23001.2
unnamed: J23001.11 (LED-R+), R23002.2

Schematic: som_decoupling.kicad_sch, SoM power-entry decoupling under the

Parts:
C35001, C35002, C35007, C35008, C35013, C35014: 22u; C_0805_2012Metric; LCSC C45783
C35003, C35004, C35005, C35006, C35009, C35010, C35011, C35012, C35015, C35016, C35017, C35018: 100n; C_0603_1608Metric; LCSC C14663

Connections:
+3V3: C35007.1, C35008.1, C35009.1, C35010.1, C35011.1, C35012.1; also elsewhere on the board
+3V3_SC: C35013.1, C35014.1, C35015.1, C35016.1, C35017.1, C35018.1; also elsewhere on the board
+5V_SOM: C35001.1, C35002.1, C35003.1, C35004.1, C35005.1, C35006.1; also elsewhere on the board
GND: C35001.2, C35002.2, C35003.2, C35004.2, C35005.2, C35006.2, C35007.2, C35008.2, C35009.2, C35010.2, C35011.2, C35012.2, C35013.2, C35014.2, C35015.2, C35016.2, C35017.2, C35018.2; also elsewhere on the board

Schematic: som_j1.kicad_sch, SoM J1: power / USB / STM32 / JTAG /

Parts:
J24001: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V_51_; LCSC C531031

Connections:
+3V3_SC: J24001.37; also elsewhere on the board
+5V_SOM: J24001.1, J24001.2, J24001.3, J24001.4, J24001.5, J24001.6, J24001.7, J24001.8, J24001.9, J24001.10, J24001.11, J24001.12, J24001.13, J24001.14; also elsewhere on the board
ETH_LED1: J24001.98
ETH_LED2: J24001.94
ETH_PHY_MDI0_N: J24001.95; also elsewhere on the board
ETH_PHY_MDI0_P: J24001.97; also elsewhere on the board
ETH_PHY_MDI1_N: J24001.89; also elsewhere on the board
ETH_PHY_MDI1_P: J24001.91; also elsewhere on the board
ETH_PHY_MDI2_N: J24001.83; also elsewhere on the board
ETH_PHY_MDI2_P: J24001.85; also elsewhere on the board
ETH_PHY_MDI3_N: J24001.77; also elsewhere on the board
ETH_PHY_MDI3_P: J24001.79; also elsewhere on the board
FMC_LA08_N: J24001.92; also elsewhere on the board
FMC_LA08_P: J24001.74; also elsewhere on the board
FMC_LA09_N: J24001.84; also elsewhere on the board
FMC_LA09_P: J24001.80; also elsewhere on the board
FMC_LA10_N: J24001.88; also elsewhere on the board
FMC_LA10_P: J24001.90; also elsewhere on the board
FMC_LA11_N: J24001.76; also elsewhere on the board
FMC_LA11_P: J24001.78; also elsewhere on the board
GND: J24001.15, J24001.16, J24001.17, J24001.18, J24001.23, J24001.28, J24001.34, J24001.39, J24001.44, J24001.51, J24001.62, J24001.63, J24001.72, J24001.75, J24001.81, J24001.82, J24001.87, J24001.93, J24001.96, J24001.99; also elsewhere on the board
IO_0_35: J24001.86
IO_L2_N_35: J24001.100
SC_INT_N: J24001.41; also elsewhere on the board
SDIO_CLK: J24001.67; also elsewhere on the board
SDIO_CMD: J24001.69; also elsewhere on the board
SDIO_D0: J24001.65; also elsewhere on the board
SDIO_D1: J24001.61; also elsewhere on the board
SDIO_D2: J24001.73; also elsewhere on the board
SDIO_D3: J24001.71; also elsewhere on the board
STM32_BOOT0: J24001.57; also elsewhere on the board
STM32_GPIO5: J24001.53; also elsewhere on the board
STM32_GPIO6: J24001.45; also elsewhere on the board
STM32_GPIO7: J24001.59; also elsewhere on the board
STM32_GPIO8: J24001.54; also elsewhere on the board
STM32_I2C2_SCL: J24001.55; also elsewhere on the board
STM32_I2C2_SDA: J24001.49; also elsewhere on the board
STM32_NRST: J24001.47; also elsewhere on the board
STM32_RAIL_EN_1V8: J24001.43; also elsewhere on the board
STM32_RAIL_EN_3V3: J24001.35; also elsewhere on the board
STM32_RAIL_EN_5V0: J24001.33; also elsewhere on the board
STM32_USB_CC1: J24001.29; also elsewhere on the board
STM32_USB_CC2: J24001.31; also elsewhere on the board
STM32_USB_D_N: J24001.21; also elsewhere on the board
STM32_USB_D_P: J24001.19; also elsewhere on the board
USB_D+: J24001.32; also elsewhere on the board
USB_D-: J24001.30; also elsewhere on the board
USB_ID: J24001.20; also elsewhere on the board
USB_VBUS: J24001.22; also elsewhere on the board
VBUS_OUT_EN: J24001.38; also elsewhere on the board
ZYNQ_PS_MIO0: J24001.50
ZYNQ_PS_MIO7/VM0: J24001.40
ZYNQ_PS_MIO8\VM1: J24001.36
ZYNQ_PS_MIO9: J24001.52
ZYNQ_PS_MIO12: J24001.46
ZYNQ_PS_UART0_RXD: J24001.42; also elsewhere on the board
ZYNQ_PS_UART0_TXD: J24001.48; also elsewhere on the board
ZYNQ_TCK: J24001.64; also elsewhere on the board
ZYNQ_TDI: J24001.70; also elsewhere on the board
ZYNQ_TDO: J24001.68; also elsewhere on the board
ZYNQ_TMS: J24001.66; also elsewhere on the board

Schematic: som_j2.kicad_sch, SoM J2: FPGA bank 13/33 IO + VCCO rails

Parts:
J25002: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V_51_; LCSC C531031

Connections:
+3V3: J25002.1, J25002.2, J25002.3, J25002.98, J25002.99, J25002.100; also elsewhere on the board
DBG_UART_RXD: J25002.42; also elsewhere on the board
DBG_UART_TXD: J25002.40; also elsewhere on the board
ESC_BUF_OE_N: J25002.57; also elsewhere on the board
ESC_FAULT_N: J25002.37; also elsewhere on the board
ESC_PWM_IN0: J25002.81; also elsewhere on the board
ESC_PWM_IN1: J25002.83; also elsewhere on the board
ESC_PWM_IN2: J25002.93; also elsewhere on the board
ESC_PWM_IN3: J25002.91; also elsewhere on the board
GND: J25002.4, J25002.5, J25002.6, J25002.15, J25002.16, J25002.25, J25002.26, J25002.35, J25002.36, J25002.45, J25002.46, J25002.55, J25002.56, J25002.65, J25002.66, J25002.75, J25002.76, J25002.85, J25002.86, J25002.95, J25002.96, J25002.97; also elsewhere on the board
HDMI_RX_5V_DET: J25002.44; also elsewhere on the board
HDMI_RX_CEC: J25002.59; also elsewhere on the board
HDMI_RX_CLK_N: J25002.88; also elsewhere on the board
HDMI_RX_CLK_P: J25002.90; also elsewhere on the board
HDMI_RX_D0_N: J25002.94; also elsewhere on the board
HDMI_RX_D0_P: J25002.92; also elsewhere on the board
HDMI_RX_D1_N: J25002.84; also elsewhere on the board
HDMI_RX_D1_P: J25002.82; also elsewhere on the board
HDMI_RX_D2_N: J25002.80; also elsewhere on the board
HDMI_RX_D2_P: J25002.78; also elsewhere on the board
IO_25_13: J25002.23; also elsewhere on the board
IO_L2_N_13: J25002.14; also elsewhere on the board
IO_L2_P_13: J25002.20; also elsewhere on the board
IO_L3_N_13: J25002.43; also elsewhere on the board
IO_L3_P_13: J25002.18; also elsewhere on the board
IO_L4_N_13: J25002.63; also elsewhere on the board
IO_L4_P_13: J25002.61; also elsewhere on the board
IO_L5P_13: J25002.38; also elsewhere on the board
IO_L5_N_13: J25002.24; also elsewhere on the board
IO_L6_P_13: J25002.21; also elsewhere on the board
IO_L6_P_33: J25002.89
IO_L7_N_13: J25002.64; also elsewhere on the board
IO_L7_P_13: J25002.62; also elsewhere on the board
IO_L8_N_13: J25002.60; also elsewhere on the board
IO_L8_P_13: J25002.58; also elsewhere on the board
IO_L9_DQS_N_13: J25002.48; also elsewhere on the board
IO_L9_DQS_P_13: J25002.50; also elsewhere on the board
IO_L10_N_13: J25002.51; also elsewhere on the board
IO_L10_P_13: J25002.53; also elsewhere on the board
IO_L15_P_13: J25002.9; also elsewhere on the board
IO_L19_P_13: J25002.12; also elsewhere on the board
IO_L21_P_13: J25002.13; also elsewhere on the board
IO_L22_P_13: J25002.19; also elsewhere on the board
IO_L24_N_13: J25002.7; also elsewhere on the board
IO_L24_P_13: J25002.10; also elsewhere on the board
LCD_CTP_INT: J25002.32; also elsewhere on the board
LCD_CTP_RST: J25002.34; also elsewhere on the board
LCD_CTP_SCL: J25002.28; also elsewhere on the board
LCD_CTP_SDA: J25002.30; also elsewhere on the board
PL_BTN0: J25002.79; also elsewhere on the board
PL_BTN1: J25002.87; also elsewhere on the board
PMODX_IO1: J25002.29; also elsewhere on the board
PMODX_IO2: J25002.27; also elsewhere on the board
PMODX_IO3: J25002.33; also elsewhere on the board
PMODX_IO4: J25002.31; also elsewhere on the board
PMODX_IO5: J25002.41; also elsewhere on the board
PMODX_IO6: J25002.39; also elsewhere on the board
PMODX_IO7: J25002.49; also elsewhere on the board
PMODX_IO8: J25002.47; also elsewhere on the board
SD_CARD_DETECT: J25002.17; also elsewhere on the board
ZYNQ_HDMI_TX_CEC: J25002.77; also elsewhere on the board
ZYNQ_HDMI_TX_HPD: J25002.54; also elsewhere on the board
ZYNQ_HDMI_TX_SCL: J25002.22; also elsewhere on the board
ZYNQ_HDMI_TX_SDA: J25002.52; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_0_N: J25002.69; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_0_P: J25002.67; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_1_N: J25002.68; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_1_P: J25002.70; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_2_N: J25002.74; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_2_P: J25002.72; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_CLK_N: J25002.73; also elsewhere on the board
ZYNQ_HDMI_TX_TMDS_CLK_P: J25002.71; also elsewhere on the board
ZYNQ_PS_UART0_CTS_N: J25002.11; also elsewhere on the board
ZYNQ_PS_UART0_RTS_N: J25002.8; also elsewhere on the board

Schematic: som_j3.kicad_sch, SoM J3: FPGA bank 33/34/35 IO + VCCO

Parts:
J26003: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V_51_; LCSC C531031

Connections:
+2V5_VADJ: J26003.1, J26003.2, J26003.4; also elsewhere on the board
+3V3: J26003.97, J26003.99; also elsewhere on the board
CAM_CLK_N: J26003.11; also elsewhere on the board
CAM_CLK_P: J26003.9; also elsewhere on the board
CAM_D0_N: J26003.7; also elsewhere on the board
CAM_D0_P: J26003.5; also elsewhere on the board
CAM_D1_N: J26003.15; also elsewhere on the board
CAM_D1_P: J26003.17; also elsewhere on the board
CAM_EN: J26003.85; also elsewhere on the board
CAM_LED: J26003.87; also elsewhere on the board
CAM_SCL: J26003.86; also elsewhere on the board
CAM_SDA: J26003.89; also elsewhere on the board
ESC_PWM_IN4: J26003.91; also elsewhere on the board
ESC_PWM_IN5: J26003.93; also elsewhere on the board
ESC_PWM_IN6: J26003.92; also elsewhere on the board
ESC_PWM_IN7: J26003.94; also elsewhere on the board
FMC_CLK0_M2C_N: J26003.16; also elsewhere on the board
FMC_CLK0_M2C_P: J26003.14; also elsewhere on the board
FMC_CLK1_M2C_N: J26003.10; also elsewhere on the board
FMC_CLK1_M2C_P: J26003.8; also elsewhere on the board
FMC_LA00_CC_N: J26003.20; also elsewhere on the board
FMC_LA00_CC_P: J26003.22; also elsewhere on the board
FMC_LA01_CC_N: J26003.26; also elsewhere on the board
FMC_LA01_CC_P: J26003.24; also elsewhere on the board
FMC_LA02_N: J26003.35; also elsewhere on the board
FMC_LA02_P: J26003.37; also elsewhere on the board
FMC_LA03_N: J26003.32; also elsewhere on the board
FMC_LA03_P: J26003.34; also elsewhere on the board
FMC_LA04_N: J26003.44; also elsewhere on the board
FMC_LA04_P: J26003.42; also elsewhere on the board
FMC_LA05_N: J26003.45; also elsewhere on the board
FMC_LA05_P: J26003.47; also elsewhere on the board
FMC_LA06_N: J26003.49; also elsewhere on the board
FMC_LA06_P: J26003.51; also elsewhere on the board
FMC_LA07_N: J26003.52; also elsewhere on the board
FMC_LA07_P: J26003.50; also elsewhere on the board
GND: J26003.3, J26003.6, J26003.12, J26003.13, J26003.18, J26003.23, J26003.28, J26003.33, J26003.38, J26003.43, J26003.48, J26003.53, J26003.58, J26003.63, J26003.68, J26003.73, J26003.80, J26003.83, J26003.90, J26003.95, J26003.100; also elsewhere on the board
IO_L16_N_35: J26003.29
IO_L16_P_35: J26003.31
IO_L18_N_35: J26003.25
IO_L18_P_35: J26003.27
IO_L22_N_34: J26003.84
IO_L23_P_34: J26003.88
IO_L24_P_34: J26003.82
LCD_B0: J26003.65; also elsewhere on the board
LCD_B1: J26003.66; also elsewhere on the board
LCD_B2: J26003.67; also elsewhere on the board
LCD_B3: J26003.69; also elsewhere on the board
LCD_B4: J26003.70; also elsewhere on the board
LCD_B5: J26003.71; also elsewhere on the board
LCD_B6: J26003.72; also elsewhere on the board
LCD_B7: J26003.74; also elsewhere on the board
LCD_BL_PWM: J26003.81; also elsewhere on the board
LCD_DE: J26003.78; also elsewhere on the board
LCD_DISP: J26003.79; also elsewhere on the board
LCD_G0: J26003.55; also elsewhere on the board
LCD_G1: J26003.56; also elsewhere on the board
LCD_G2: J26003.57; also elsewhere on the board
LCD_G3: J26003.59; also elsewhere on the board
LCD_G4: J26003.60; also elsewhere on the board
LCD_G5: J26003.61; also elsewhere on the board
LCD_G6: J26003.62; also elsewhere on the board
LCD_G7: J26003.64; also elsewhere on the board
LCD_HSYNC: J26003.76; also elsewhere on the board
LCD_PCLK: J26003.75; also elsewhere on the board
LCD_R0: J26003.19; also elsewhere on the board
LCD_R1: J26003.21; also elsewhere on the board
LCD_R2: J26003.30; also elsewhere on the board
LCD_R3: J26003.36; also elsewhere on the board
LCD_R4: J26003.40; also elsewhere on the board
LCD_R5: J26003.41; also elsewhere on the board
LCD_R6: J26003.46; also elsewhere on the board
LCD_R7: J26003.54; also elsewhere on the board
LCD_VSYNC: J26003.77; also elsewhere on the board
PUDC_34: J26003.39; also elsewhere on the board
WATCHDOG_KICK: J26003.96; also elsewhere on the board
WATCHDOG_RST_N: J26003.98; also elsewhere on the board
